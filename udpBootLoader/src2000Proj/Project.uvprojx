# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  BeforeMake: python.exe ../../toolchain/updateIP.py
  AfterMake: fromelf.exe --bin -o "$L@L.sc2b.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,USE_SEER_ASSERT,RUN_FOR_SRC_2000
  c misc: --cpp --cpp11
  c include: ..\..\Libraries\FWlib\inc;..\Startup;..\User;..\wiznet;..\iap;..\..\Libraries\CMSIS\inc;..\..\logger;..\..\HAL;..\..\utility;..\..\NetworkAdapter;..\..\socket;..\..\protobuffer;..\..\LWIP;..\..\LWIP\arch;..\..\LWIP\lwip_header;..\..\LWIP\app\TCP_Client;..\..\LWIP\lwip_app\lwip_comm;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\LWIP\lwip_app\lwip_comm;.\opts;..\..\RTL8370MB\API;..\..\RTL8370MB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.cpp udpDevice.cpp HeartLed.c powerupDefaultValue.cpp
  group FWlib
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_syscfg.c
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group Doc
    ../../iapTools/: iapBlFlasher.py
  group IAP
    ../iap/: iap.c st_bootloader_protocol.c
  group logger
    ../../logger/: CCanConsole.cpp Console.cpp CUartConsole.cpp CUdpConsole.cpp SEGGER_RTT.c
  group HAL
    ../../HAL/: CommonConfig.c CCan.cpp CUsart.cpp Timer.cpp watchDog.cpp CSpi.cpp stmflash.c powerupOption.cpp
  group NetworkAdapter
    ../../NetworkAdapter/RTL8370MB/: NetworkAdapter.cpp
  group socket
    ../../socket/: byteston.c
    ../../socket/LAN8720/: socket.c
  group lwip-common
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group lwip-netif
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwip-core
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group lwip-arch
    ../../LWIP/arch/: sys_arch.c
  group lwip-api
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group RTL8370MB
    ../../RTL8370MB/: RTL8370MB.c sim_smi.c stm32f4x7_rtl8370mb_eth.c
    ../../RTL8370MB/API/: port.c rtk_switch.c interrupt.c led.c rtl8367c_asicdrv.c rtk_cpu.c rtl8367c_asicdrv_phy.c rtl8367c_asicdrv_port.c rtl8367c_asicdrv_led.c rtl8367c_asicdrv_interrupt.c rtl8367c_asicdrv_rma.c rtl8367c_asicdrv_cputag.c rtl8367c_asicdrv_lut.c rtl8367c_asicdrv_mirror.c smi.c rtl8367c_asicdrv_misc.c rtl8367c_asicdrv_scheduling.c rtl8367c_asicdrv_inbwctrl.c
software components: CMSIS:CORE 5.0.1
